# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\compare;..\HARDWARE\fingerprint;..\HARDWARE\Instruction;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\RFID;..\HARDWARE\RTC;..\HARDWARE\TEXT;..\HARDWARE\TIM;..\HARDWARE\ZigBee;..\HARDWARE\MY_MATH;..\HARDWARE\WDG;..\PICTURE;..\HARDWARE\SDIO;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/compare/: compare.c
    ../HARDWARE/fingerprint/: fingerprint.c
    ../HARDWARE/Instruction/: Instruction.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c text.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RFID/: rc522.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIM/: timer.c
    ../HARDWARE/ZigBee/: ZigBee.c
    ../HARDWARE/MY_MATH/: my_math.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
